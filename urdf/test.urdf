Commit message: Update test.urdf

File: urdf/test.urdf (robot description, URDF)
Before this commit: robot robotino, 13 links, 12 joints
Joints:
- joint camera_rgb_joint: origin xyz=0.51 0.008 0.49 rpy=0 0 0 -> xyz=0.205 0.008 0.495 rpy=0 0 0
